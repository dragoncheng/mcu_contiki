# Keil uVision project Project.uvproj, settings and files
target GD32F10X_CL (ARM-ADS)
  device: GD32F107VC GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_CL
  c include: ..\..\..\firmware\GD32F10x_Firmware_Library\Firmware\GD32F10x_standard_peripheral\Include;..\..\..\firmware\GD32F10x_Firmware_Library\Firmware\CMSIS\GD\GD32F10x\Include;..\..\..\firmware\GD32F10x_Firmware_Library\Firmware\CMSIS;..\..\Utilities;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group CMSIS
    ../../../firmware/GD32F10x_Firmware_Library/Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Peripherals
    ../../../firmware/GD32F10x_Firmware_Library/Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_bkp.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_exmc.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_i2c.c gd32f10x_pmu.c gd32f10x_rtc.c gd32f10x_spi.c gd32f10x_usart.c gd32f10x_wwdgt.c gd32f10x_rcu.c gd32f10x_exti.c gd32f10x_adc.c gd32f10x_can.c gd32f10x_dbg.c gd32f10x_enet.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_dma.c gd32f10x_timer.c gd32f10x_sdio.c
  group Startup
    ../../../firmware/GD32F10x_Firmware_Library/Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_cl.s startup_gd32f10x_hd.s startup_gd32f10x_md.s startup_gd32f10x_xd.s
  group contiki-core-dev
    ../../../contiki/core/dev/: serial-line.c
  group contiki-core-lib
    ../../../contiki/core/lib/: list.c print-stats.c ringbuf.c
  group contiki-core-net
    ../../../contiki/core/net/: linkaddr.c
  group contiki-core-sys
    ../../../contiki/core/sys/: autostart.c process.c timer.c etimer.c
  group contiki-cpu
    ../../../contiki/cpu/arm/gd32f103/: clock.c debug-uart.c
  group contiki-serial-shell
    ../../../contiki/apps/serial-shell/: serial-shell.c
  group contiki-shell
    ../../../contiki/apps/shell/: shell.c
  group BSP
    ../../../board/adcan/: adcan_bsp.c adcan_bsp_eval.c adcan_bsp_uart.c
  group Doc
    ../: readme.txt
  group user
    ../: contiki-main.c gd32f10x_it.c
target GD32F10X_MD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103T8 GigaDevice
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD,SHELL_CONF_PROMPT,SHELL_CONF_BANNER
  c include: ..\..\..\firmware\GD32F10x_Firmware_Library\Firmware\GD32F10x_standard_peripheral\Include;..\..\..\firmware\GD32F10x_Firmware_Library\Firmware\CMSIS\GD\GD32F10x\Include;..\..\Utilities;..\..\..\firmware\GD32F10x_Firmware_Library\Firmware\CMSIS;..\;..\..\..\contiki\core;..\..\..\contiki\cpu\arm\common;..\..\..\board;..\..\..\contiki\cpu\arm\gd32f103;..\..\..\contiki\apps
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target GD32F10X_HD (ARM-ADS)
  device: GD32F103VC GigaDevice
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x08000000-0x0803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c include: ..\..\..\firmware\GD32F10x_Firmware_Library\Firmware\GD32F10x_standard_peripheral\Include;..\..\..\firmware\GD32F10x_Firmware_Library\Firmware\CMSIS\GD\GD32F10x\Include;..\..\Utilities;..\..\..\firmware\GD32F10x_Firmware_Library\Firmware\CMSIS;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target GD32F10X_XD (ARM-ADS)
  device: GD32F103VK GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x082FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_XD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x18000
